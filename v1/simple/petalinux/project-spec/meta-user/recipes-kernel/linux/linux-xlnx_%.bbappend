SRC_URI += "file://user_2020-04-16-13-31-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

