# start fancontrol.service automatically
SYSTEMD_AUTO_ENABLE = "enable"
