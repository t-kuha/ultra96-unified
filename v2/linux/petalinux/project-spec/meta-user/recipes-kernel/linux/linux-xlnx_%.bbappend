SRC_URI += "file://user_2020-04-18-19-59-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

