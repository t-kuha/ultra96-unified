SRC_URI += "file://user_2020-04-16-14-32-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

